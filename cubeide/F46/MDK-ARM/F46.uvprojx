# Keil uVision project F46.uvprojx, settings and files
target F46 (6220000::V6.22::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: F46 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F407xE,STM32,STM32F4,STM32F46,STM32F4_6
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\App\bsp;..\App\grbl
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_rcc.c stm32f4xx_ll_utils.c stm32f4xx_ll_exti.c stm32f4xx_hal_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_gpio.c stm32f4xx_ll_dma.c stm32f4xx_hal_uart.c stm32f4xx_ll_usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group bsp
    ../App/bsp/: inoutputs.c stm32utilities.c g6core.h g32core.h inoutputs.h stm32_cpu_map.h stm32_pin_out.h stm32eeprom.h stm32utilities.h
  group grbl
    ../App/grbl/: config.h coolant_control.c coolant_control.h cpu_map.h defaults.h eeprom.c eeprom.h gcode.c gcode.h grbl.h jog.c jog.h limits.c limits.h motion_control.c motion_control.h nuts_bolts.c nuts_bolts.h planner.c planner.h print.c print.h probe.c probe.h protocol.c protocol.h report.c report.h serial.c serial.h settings.c settings.h spindle_control.c spindle_control.h stepper.c stepper.h system.c system.h
software components: CMSIS:CORE 6.1.0
